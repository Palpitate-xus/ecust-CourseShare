# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LV52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c hd7279a.c ds18b20.c common.c motor.c ee24c16.c para.c pid.c
